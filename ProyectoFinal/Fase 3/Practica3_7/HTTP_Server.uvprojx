# Keil uVision project HTTP_Server.uvprojx, settings and files
target LPC1758 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1758 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: HTTP_Server.c pinoutConfigure.c pinoutConfigure.h HTTP_Server_CGI.c HTTP_Server_CGI.h adc.c adc.h Arial12x12.h LCD.c LCD.h RTC.c RTC.h SNTP.c SNTP.h gestor_pulsador.c gestor_pulsador.h gestion_FLASH.c gestion_FLASH.h lpc17xx_iap.c lpc17xx_iap.h lpc_types.h Led_RGB.c Led_RGB.h
    Web/: Web.c
  group Web files
    ./Web/: index.htm network.cgi pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif llblue.jpg logo.gif pabb.gif RTC.cgi RTC.cgx UC.cgi UC.cgx
  group Documentation
    ./: Abstract.txt
target LPC1768 Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: as above
  output: HTTP_Server
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, Network:CORE 6.7.7, Network:Interface:ETH 6.7.7, Network:Service:SNTP Client 6.7.7, Network:Service:Web Server Compact 6.7.7, Network:Socket:TCP 6.7.7, Network:Socket:UDP 6.7.7, CMSIS Driver:Ethernet MAC 2.11.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
