# Keil uVision project Practica3_4.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P1_2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: principal.c lpc17xx_iap.c lpc17xx_iap.h lpc_types.h gestion_FLASH.c gestion_FLASH.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
